# Keil uVision project Quick_regression_cal.uvprojx, settings and files
target ble_freq_sweep (5060960::V5.06 update 7 (build 960)::.\ARM_Compoler_5.06u7)
  device: ARMCM0 ARM
  pack: ARM.CMSIS.5.9.0
  cpu: IROM(0x00000000,0x80000) IRAM(0x20000000,0x20000) CPUTYPE("Cortex-M0") CLOCK(10000000) ELITTLE
  output: Quick_regression_cal +hex
  AfterMake: fromelf --bin .\Objects\Quick_regression_cal.axf -o .\Objects\Quick_regression_cal.bin
  AfterMake: fromelf -cvf .\Objects\Quick_regression_cal.axf -o .\Objects\disasm.txt
  c flags: Optim=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: ../../
  memory RVCT4: ROM 0x0 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group app
    ./: Quick_regression_cal.c
  group drv
    ../../: cm0dsasm.s Memory_Map.h retarget.c optical.c optical.h radio.c radio.h adc.c adc.h gpio.c gpio.h uart.c uart.h rftimer.c rftimer.h scum_defs.h scm3c_hw_interface.h scm3c_hw_interface.c ble.c ble.h
